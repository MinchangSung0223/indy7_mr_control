Commit message: 0112

File: model/indy7.urdf (robot description, URDF)
Before this commit: robot indy7, 9 links, 8 joints
Links:
- link tcp: geometry collision box size=0.01 0.01 0.01
